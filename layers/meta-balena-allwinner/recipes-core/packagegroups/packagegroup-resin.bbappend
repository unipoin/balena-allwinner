RDEPENDS_${PN}_append_nanopi-neo-air = " brcm-patchram-plus \
	nanopi-air-bt \
"

RDEPENDS_${PN}_append_gridless-mini = " \
	i2c-tools \
	usbutils \
"